# Keil uVision project M0_SOC.uvprojx, settings and files
target soc_m0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code +hex
  BeforeMake: C:\Windows\System32\cmd.exe  /c copy ..\TN2115s_lib\*.* .\APP\TN2115s_libs
  AfterMake: fromelf -cvf .\objects\code.axf --vhx --32x1 -o code.hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APP;.\APP\TN2115s_libs;.\Common\CMSIS-FreeRTOS\10.0.1\Source\include;.\Common\RTE\RTOS;.\Common\CMSIS-FreeRTOS\10.0.1\CMSIS\RTOS2\FreeRTOS\Include;.\Common\CMSIS-FreeRTOS\10.0.1\Source\portable\RVDS\ARM_CM0;.\APP\EINK;.\Device_desc;.\Common\CMSIS-FreeRTOS\10.0.1\Source;.\Common\RTE\Device\ARMCM0
  asm include: .\APP\UART;.\APP\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  memory RVCT10: RAM 0x20001000 size 0x1000
  scatter file: .\Common\TN2115S1.sct
  group MAIN
    ./APP/: main.c project.h
  group Eink_Driver
    ./APP/EINK/: EINK_Driver.c EINK_Driver.h
  group RTOS
    ./Common/CMSIS-FreeRTOS/10.0.1/Source/: list.c queue.c tasks.c timers.c event_groups.c
    ./Common/CMSIS-FreeRTOS/10.0.1/Source/portable/MemMang/: heap_4.c
    ./Common/RTE/RTOS/: FreeRTOSConfig.h
    ./Common/CMSIS-FreeRTOS/10.0.1/CMSIS/RTOS2/FreeRTOS/Source/: freertos_evr.c
    ./Common/CMSIS-FreeRTOS/10.0.1/Source/portable/RVDS/ARM_CM0/: port.c portmacro.h
  group TN2115s0_lib
    ./APP/TN2115s_libs/: macros.h TN2115s.lib config.c TN2115s_oslib.h
  group Startup
    ./Common/RTE/Device/ARMCM0/: startup_ARMCM0.s
software components: CMSIS:CORE 5.4.0
